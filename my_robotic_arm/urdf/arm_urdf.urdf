Commit message: moveit servo setup

File: my_robotic_arm/urdf/arm_urdf.urdf (robot description, URDF)
Before this commit: robot arm_urdf, 18 links, 17 joints
Joints:
- joint Joint_5: limit lower=-0.065 upper=3.17 effort=50 velocity=5 -> lower=-3.14 upper=3.17 effort=50 velocity=5
